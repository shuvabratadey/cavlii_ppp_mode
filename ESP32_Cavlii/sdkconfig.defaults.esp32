## ESP32_Cavlii/sdkconfig.defaults.esp32
```kconfig
CONFIG_BLINK_GPIO=5
CONFIG_ESPTOOLPY_FLASHSIZE_8MB=y
CONFIG_ESP_MAIN_TASK_STACK_SIZE=8192
```
